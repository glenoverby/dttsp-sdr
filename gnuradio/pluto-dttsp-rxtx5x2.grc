options:
  parameters:
    category: Custom
    description: interface to DTTSP
    generate_options: no_gui
    id: pluto_dttsp_rxtx5x2
    output_language: python
    run_options: run
    title: Pluto SDR Transceiver
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '432100000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '22'
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: oversampling
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rx_bandwidth
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rx_lpf2_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_lpf_cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: rx_lpf_width
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: output_rate*oversampling
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_lpf_cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: tx_lpf_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_lpf_width
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: txenable
  id: variable
  parameters:
    value: '1'
  states: {}
- name: txinput
  id: variable
  parameters:
    value: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pluto_rx
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: pluto_rx2
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pluto_tx
    num_outputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: pluto_tx2
    num_outputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rx_lpf2_freq
    decim: int(samp_rate/output_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, samp_rate/(4),16384)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-rx_lpf2_freq'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, samp_rate/(4),16384)
    type: ccc
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: frequency
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ''
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: frequency
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    type: fc32
    uri: ''
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rx_lpf_cutoff
    decim: int(samp_rate/output_rate)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: rx_lpf_width
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: tx_lpf_cutoff
    gain: tx_lpf_gain
    interp: int(samp_rate/output_rate)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: tx_lpf_width
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: tx_lpf_cutoff
    gain: tx_lpf_gain
    interp: int(samp_rate/output_rate)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: tx_lpf_width
    win: window.WIN_BLACKMAN
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [audio_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [audio_source_0_0, '1', blocks_float_to_complex_0_0, '1']
- [blocks_add_xx_0, '0', iio_fmcomms2_sink_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', audio_sink_0_0, '1']
- [blocks_float_to_complex_0, '0', low_pass_filter_0_0_0_0_1, '0']
- [blocks_float_to_complex_0_0, '0', low_pass_filter_0_0_0_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '1']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0_0_0_0_1, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_0_0_0_1_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
