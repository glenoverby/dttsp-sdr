options:
  parameters:
    category: Custom
    description: interface to DTTSP
    generate_options: no_gui
    id: lime_dttsp_rxtx1x1
    output_language: python
    run_options: run
    title: LimeSDR Transceiver
  states: {}

blocks:
- name: analog_filter
  id: variable
  parameters:
    value: 15e5
  states: {}
- name: digital_filter
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '50200000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: nco_frequency
  id: variable
  parameters:
    value: '0'
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: oversampling
  id: variable
  parameters:
    value: '48'
  states: {}
- name: rx_antenna
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_lpf2_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_lpf_cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: rx_lpf_width
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: output_rate*oversampling
  states: {}
- name: tx_analog_filter
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_antenna
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_digital_filter
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: tx_lpf_cutoff
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: tx_lpf_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_lpf_width
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: lime_rx
    num_inputs: '2'
    samp_rate: output_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: lime_rx2
    num_inputs: '2'
    samp_rate: output_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: lime_tx
    num_outputs: '2'
    samp_rate: output_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rx_lpf2_freq
    decim: int(samp_rate/output_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, samp_rate/(2*oversampling),16384)
    type: ccc
  states: {state: disabled}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: tx_analog_filter
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: tx_digital_filter
    digital_bandw_ch1: '0'
    gain_dB_ch0: tx_gain
    gain_dB_ch1: '30'
    nco_freq_ch0: nco_frequency
    oversample: '16'
    pa_path_ch0: tx_antenna
    pa_path_ch1: '1'
    rf_freq: frequency
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: analog_filter
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: digital_filter
    digital_bandw_ch1: '0'
    gain_dB_ch0: gain
    gain_dB_ch1: '30'
    lna_path_ch0: rx_antenna
    nco_freq_ch0: nco_frequency
    oversample: '16'
    rf_freq: frequency
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rx_lpf_cutoff
    decim: int(samp_rate/output_rate)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: rx_lpf_width
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: tx_lpf_cutoff
    gain: tx_lpf_gain
    interp: int(samp_rate/output_rate)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: tx_lpf_width
    win: window.WIN_BLACKMAN
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', audio_sink_0_0, '1']
- [blocks_float_to_complex_0, '0', low_pass_filter_0_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0_0, '0']
- [limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0_0_0_0_1, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
