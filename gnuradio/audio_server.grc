options:
  parameters:
    author: glen
    generate_options: no_gui
    id: audio_server
    output_language: python
    run_options: run
    title: Audio output to network
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: gr_sink
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: callisto.local
    header: '0'
    payloadsize: '1472'
    port: '20001'
    send_eof: 'False'
    type: float
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    port: '20000'
    src_zeros: 'False'
    type: float
  states: {}

connections:
- [audio_source_0, '0', network_udp_sink_0, '0']
- [network_udp_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
